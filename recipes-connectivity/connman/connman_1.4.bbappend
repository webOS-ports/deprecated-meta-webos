# (c) Copyright 2012-2013 Hewlett-Packard Development Company, L.P.

PRINC := "${@int(PRINC) + 2}"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
